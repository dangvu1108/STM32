# Keil uVision project Unit9_DMA.uvprojx, settings and files
target Project_DMA (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Unit9_DMA
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\LIB\inc;..\LIB\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: main.c
  group Lib
    ../LIB/src/: dma.c TIMER.c UART.c adc.c
software components: CMSIS:CORE 4.3.0, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
